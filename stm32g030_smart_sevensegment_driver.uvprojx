# Keil uVision project stm32g030_smart_sevensegment_driver.uvprojx, settings and files
target STM32G030F6P6 (6160000::V6.16::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: stm32g030_smart_sevensegment_driver
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group inc
    ./: app.h defs.h
  group src
    ./: main.c app.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.4.2
